require sdv-canbus-modules.inc

