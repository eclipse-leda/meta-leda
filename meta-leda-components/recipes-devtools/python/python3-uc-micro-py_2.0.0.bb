SUMMARY = "Micro subset of Unicode data for linkify-it-py"
HOMEPAGE = "https://github.com/tsutsu3/uc.micro-py"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=2bdce4f0cca8b092dd7889cef7f7fe20"

PYPI_PACKAGE = "uc_micro_py"
SRC_URI[sha256sum] = "c53691e495c8db60e16ffc4861a35469b0ba0821fe409a8a7a0a71864d33a811"

inherit pypi python_setuptools_build_meta
